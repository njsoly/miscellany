# Keil uVision project lnFlwr_kl25z.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.11.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lnFlwr_kl25z
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\uvision;..\lnFlwr_kl25z
  asm include: ..\lnFlwr_kl25z;..\..\uvision
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ../: Epson_Defs.h FONT8x16.h fun_with_preproc.h
    ./: main.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 2.5.0
